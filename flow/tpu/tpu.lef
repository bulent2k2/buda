# tpu.lef -- generated by flow/tcl/tpu.tcl -emit; do not edit.
VERSION 5.8 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;
UNITS
  DATABASE MICRONS 1000 ;
END UNITS

MACRO pe_cell
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 152 BY 56 ;
  SYMMETRY X Y ;
END pe_cell

MACRO feed_cell
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 152 BY 56 ;
  SYMMETRY X Y ;
END feed_cell

MACRO wbuf_cell
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 152 BY 56 ;
  SYMMETRY X Y ;
END wbuf_cell

MACRO acc_cell
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 152 BY 56 ;
  SYMMETRY X Y ;
END acc_cell

END LIBRARY
